Commit message: Pose filtering and collision geo improvements

File: workspace-config/yam_collision.urdf (robot description, URDF)
Before this commit: robot yam, 10 links, 9 joints
Joints:
- joint gripper_tip_joint: origin xyz=0 0 -0.1 rpy=0 0 0 -> xyz=0 0 -0.12 rpy=0 0 0
